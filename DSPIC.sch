File: DSPIC.sch (KiCad schematic (older format))
At the start: 46 parts

Commit message: actual
Parts:
- gave numbers to parts that had none: 46
