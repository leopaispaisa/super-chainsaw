File: ETHERNET.sch (KiCad schematic (older format))
At the start: 28 parts

Commit message: actual
Parts:
- gave numbers to parts that had none: 27
Connections:
- wire segments 122 -> 120
