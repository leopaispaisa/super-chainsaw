File: RELES_SENSORES.sch (KiCad schematic (older format))
At the start: 64 parts

Commit message: actual
Parts:
- gave numbers to parts that had none: 64
